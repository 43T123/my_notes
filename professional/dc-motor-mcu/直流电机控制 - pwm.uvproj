# Keil uVision project 直流电机控制 - pwm.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 直流电机控制 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main - pwm.c
